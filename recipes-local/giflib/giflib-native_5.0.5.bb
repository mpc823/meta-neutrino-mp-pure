require giflib_${PV}.bb

S = "${UNPACKDIR}/giflib-${PV}"

PACKAGES = ""

inherit autotools native
